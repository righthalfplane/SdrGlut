options:
  parameters:
    generate_options: qt_gui
    id: LimeTest
    output_language: python
    title: LimeTest
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: '101500000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"soapy=1,driver=lime"'
    bb_gain0: '20'
    freq0: frequency
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
