options:
  parameters:
    category: Custom
    description: https://apollo.open-resource.org/mission:log:2012:05:06:rtlsdr-osmosdr-gnuradio-fm-receiver
    generate_options: qt_gui
    id: osmo_nfm_rx
    output_language: python
    run_options: run
    title: OSMOSDR NFM RX
  states: {}

blocks:
- name: RF_Gain
  id: variable
  parameters:
    value: '24'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '497050000'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: '569000000'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: '629000000'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: '503000000'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '183000000'
  states: {state: disabled}
- name: freq
  id: variable
  parameters:
    value: '605000000'
  states: {state: disabled}
- name: gain_0
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '200'
    value: '40'
  states: {}
- name: s_rate
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /Users/dir/Desktop/atsc-tv/mpegOut.ts
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    begin_tag: '0'
    file: /Users/dir/Desktop/atsc-tv/sndtestOK.wav
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain_0
    type: complex
  states: {}
- name: blocks_tcp_server_sink_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: ''
    noblock: 'True'
    port: ''
    type: byte
    vlen: '1'
  states: {state: disabled}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'False'
    ipaddr: 192.168.0.2
    port: '1234'
    psize: '512'
    type: byte
    vlen: '1'
  states: {state: disabled}
- name: dc_blocker_xx_1
  id: dc_blocker_xx
  parameters:
    length: '4096'
    long_form: 'False'
    type: cc
  states: {state: disabled}
- name: dtv_atsc_rx_0
  id: dtv_atsc_rx
  parameters:
    rate: s_rate
    sps: '1.1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 8e6
    analog_bandw_ch1: 5e6
    calibr_bandw_ch0: 8e6
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: '30'
    gain_dB_ch1: '30'
    oversample: '1'
    rf_freq: freq
    samp_rate: s_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: s_rate
    fc: freq
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: s_rate
    fc: freq
    fftsize: '1024'
    showports: 'True'
    type: float
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_file_source_0_0_0, '0', dc_blocker_xx_1, '0']
- [blocks_multiply_const_vxx_0, '0', dtv_atsc_rx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [dtv_atsc_rx_0, '0', blocks_char_to_float_0, '0']
- [dtv_atsc_rx_0, '0', blocks_file_sink_0, '0']
- [dtv_atsc_rx_0, '0', blocks_tcp_server_sink_0, '0']
- [dtv_atsc_rx_0, '0', blocks_udp_sink_0, '0']
- [limesdr_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
