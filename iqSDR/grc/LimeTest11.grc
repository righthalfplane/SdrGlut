options:
  parameters:
    generate_options: qt_gui
    id: LimeTest
    output_language: python
    title: LimeTest
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: '605000000'
  states: {state: disabled}
- name: frequency
  id: variable
  parameters:
    value: '605000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/dir/Desktop/testWrite.raw
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10000'
    type: complex
  states: {}
- name: dtv_atsc_rx_0
  id: dtv_atsc_rx
  parameters:
    rate: samp_rate
    sps: '1.1'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: 127.0.0.1
    mode: '1'
    port: '3700'
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_sdrplay_source_0
  id: soapy_sdrplay_source
  parameters:
    antenna: Antenna A
    bandwidth: '10000000'
    center_freq: frequency
    dev_args: soapy=0
    gain: '-25'
    lna_state: '0'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', dtv_atsc_rx_0, '0']
- [dtv_atsc_rx_0, '0', blocks_char_to_float_0, '0']
- [dtv_atsc_rx_0, '0', blocks_file_sink_0, '0']
- [dtv_atsc_rx_0, '0', network_tcp_sink_0, '0']
- [soapy_sdrplay_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [soapy_sdrplay_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_sdrplay_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
